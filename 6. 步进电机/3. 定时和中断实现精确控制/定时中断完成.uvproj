# Keil uVision project 定时中断完成.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 定时中断完成 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 定时中断完成.c
