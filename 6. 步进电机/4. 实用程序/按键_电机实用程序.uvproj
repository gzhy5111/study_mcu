# Keil uVision project 按键_电机实用程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 按键_电机实用程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 按键_电机实用程序.c
    D:/Keil_v5/C51/LIB/: C51S.LIB
