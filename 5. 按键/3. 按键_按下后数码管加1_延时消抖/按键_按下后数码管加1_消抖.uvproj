# Keil uVision project 按键_按下后数码管加1_消抖.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 按键_按下后数码管加1_消抖 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 按键_按下后数码管加1_消抖.c
